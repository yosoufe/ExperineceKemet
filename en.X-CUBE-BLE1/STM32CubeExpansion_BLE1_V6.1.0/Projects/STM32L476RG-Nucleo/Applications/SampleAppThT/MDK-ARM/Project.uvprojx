# Keil uVision project Project.uvprojx, settings and files
target SampleApp_SERVER (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: SampleApp_SERVER +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L476xx,USE_STM32L4XX_NUCLEO,USE_HAL_DRIVER,SERVER_ROLE
  c include: ../Inc;../../../../../Middlewares/ST/BlueNRG-MS/includes;../../../../../Middlewares/ST/BlueNRG-MS/utils;../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32L4xx_Nucleo;../../../../../Drivers/BSP/X-NUCLEO-IDB0xA1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: hci_tl.c main.c cube_hal_l4.c hci_tl_interface.c gp_timer.c sample_service.c stm32l4xx_it.c uart_support.c stm32l4xx_hal_msp.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L476RG_NUCLEO
    ../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDB0xA1
    ../../../../../Drivers/BSP/X-NUCLEO-IDB0xA1/: stm32_bluenrg_ble.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_flash_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_uart.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rcc.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal.c stm32l4xx_hal_pwr.c stm32l4xx_hal_spi.c
  group Middlewares/BlueNRG-MS/Wireless/Controller
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/controller/: bluenrg_l2cap_aci.c bluenrg_hal_aci.c bluenrg_gap_aci.c bluenrg_utils_small.c bluenrg_gatt_aci.c
  group Middlewares/BlueNRG-MS/Wireless/HCI_TL/Template
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/: hci_le.c
  group Middlewares/BlueNRG-MS/Wireless/Utils
    ../../../../../Middlewares/ST/BlueNRG-MS/utils/: ble_list.c
target SampleApp_CLIENT (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: as above
  output: SampleApp_CLIENT
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L476xx,USE_STM32L4XX_NUCLEO,USE_HAL_DRIVER,CLIENT_ROLE
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target ThroughputTest_SERVER (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: as above
  output: ThroughputTest_SERVER
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L476xx,USE_STM32L4XX_NUCLEO,USE_HAL_DRIVER,SERVER_ROLE,THROUGHPUT_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target ThroughputTest_CLIENT (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: as above
  output: ThroughputTest_CLIENT
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L476xx,USE_STM32L4XX_NUCLEO,USE_HAL_DRIVER,CLIENT_ROLE,THROUGHPUT_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
software components: CMSIS:CORE 4.3.0
