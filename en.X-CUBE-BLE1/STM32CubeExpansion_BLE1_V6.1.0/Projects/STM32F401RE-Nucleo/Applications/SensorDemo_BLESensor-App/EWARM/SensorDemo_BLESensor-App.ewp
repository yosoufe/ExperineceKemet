# IAR project SensorDemo_BLESensor-App.ewp, settings and files
configuration SensorDemo_BLESensor-App (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE
  ICCARM.CCIncludePath2: ../Inc; ../../../../../Drivers/STM32F4xx_HAL_Driver/Inc; ../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Middlewares/ST/BlueNRG-MS/utils; ../../../../../Middlewares/ST/BlueNRG-MS/includes; ../../../../../Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SensorDemo_BLESensor-App_F401RE.bin
  ILINK.IlinkOutputFile: SensorDemo_BLESensor-App.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f401xe.s
  group Application/User
    ../Src/: main.c hci_tl_interface.c gatt_db.c sensor.c app_bluenrg_ms.c stm32f4xx_nucleo_bus.c stm32f4xx_nucleo.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Doc
    C:/BlueNRG-MS_git-repo/X-CUBE-BLE1/Firmware/Projects/STM32F401RE-Nucleo/Applications/SensorDemo_BLESensor-App/: readme.txt
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/BlueNRG-MS/Wireless/BlueNRG-MS/Utils
    ../../../../../Middlewares/ST/BlueNRG-MS/utils/: ble_list.h ble_list_utils_template.h ble_list.c
  group Middlewares/BlueNRG-MS/Wireless/BlueNRG-MS/Controller
    ../../../../../Middlewares/ST/BlueNRG-MS/includes/: bluenrg_aci.h bluenrg_aci_const.h bluenrg_conf_template.h bluenrg_def.h bluenrg_gap.h bluenrg_gap_aci.h bluenrg_gatt_aci.h bluenrg_gatt_server.h bluenrg_hal_aci.h bluenrg_l2cap_aci.h bluenrg_types.h bluenrg_updater_aci.h bluenrg_utils.h hci.h hci_const.h hci_le.h link_layer.h sm.h compiler.h
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_updater_aci.c bluenrg_utils_small.c
  group Middlewares/BlueNRG-MS/Wireless/BlueNRG-MS/HCI_TL/Basic
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic/: hci_tl.h hci_tl.c
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/: hci_le.c
